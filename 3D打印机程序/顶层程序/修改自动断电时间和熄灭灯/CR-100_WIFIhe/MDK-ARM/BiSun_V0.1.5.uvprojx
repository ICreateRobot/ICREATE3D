# Keil uVision project BiSun_V0.1.5.uvprojx, settings and files
target BiSun_V0.1.5 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BiSun_V0.1.5 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\Libraries\Core;..\Libraries\Inc;..\Libraries\Inc\Legacy;..\User;..\User\Peripheral;..\User\Printer;..\User\FatFs;..\User\LCD
  memory RVCT4: ROM 0x8019000 size 0x64000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c system.c usart.c adc.c iic.c timer.c sdio.c malloc.c rtc.c ws2812.c
  group Peripheral
    ../User/Peripheral/: sd_card.c stepper_motor.c temperature.c endstop.c oled.c keypad.c remote.c
  group Printer
    ../User/Printer/: printer.c planner.c hmi.c storage_device.c gcode.h
  group FatFs
    ../User/: fatfs.c
    ../User/FatFs/: diskio.c ff.c ffsystem.c ffunicode.c
  group Startup
    ../Libraries/Core/: startup_stm32f103xe.s cmsis_armcc.h core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group System
    ../Libraries/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_it.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c system_stm32f1xx.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c
